# Keil uVision project nRF52_DFU.uvprojx, settings and files
target nRF52_xxAA_S132 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: SENSOR_EM7028 CONFIG_USING_ANCS=1 CONFIG_USING_WECHAT=1 CONFIG_USING_FPU=1 BLE_DFU_APP_SUPPORT BLE_STACK_SUPPORT_REQD S132 NRF52_PAN_24 NRF52_PAN_25 NRF52_PAN_26 NRF52_PAN_27 NRF52_PAN_28 NRF52_PAN_29 NRF52_PAN_30 NRF52_PAN_32 NRF52_PAN_33 NRF52_PAN_34 NRF52_PAN_35 NRF52_PAN_36 NRF52_PAN_37 NRF52_PAN_38 NRF52_PAN_39 NRF52_PAN_40 NRF52_PAN_41 NRF52_PAN_42 NRF52_PAN_43 NRF52_PAN_44 NRF52_PAN_46 NRF52_PAN_47 NRF52_PAN_48 NRF52_PAN_49 NRF52_PAN_58 NRF52_PAN_63 NRF52_PAN_64 NRF52_PAN_65 CONFIG_GPIO_AS_PINRESET  NRF52_PAN_1 NRF52_PAN_2 NRF52_PAN_3 NRF52_PAN_4 NRF52_PAN_7 NRF52_PAN_8 NRF52_PAN_9 NRF52_PAN_10 NRF52_PAN_11 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_16 NRF52_PAN_17 NRF52_PAN_20 NRF52_PAN_23 NRF_LOG_USES_UART=0 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF52
  c include: .\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\common;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\hal;.\nRF5_SDK_11.0.0_89a8197\components\libraries\util;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\delay;.\nRF5_SDK_11.0.0_89a8197\components\softdevice\s132\headers;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_services\ble_dfu;.\nRF5_SDK_11.0.0_89a8197\components\ble\common;.\nRF5_SDK_11.0.0_89a8197\components\libraries\bootloader_dfu;.\nRF5_SDK_11.0.0_89a8197\components\ble\device_manager;.\nRF5_SDK_11.0.0_89a8197\components\ble\device_manager\config;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_advertising;.\nRF5_SDK_11.0.0_89a8197\components\softdevice\common\softdevice_handler;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_services\ble_nus;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\pstorage;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\pstorage\config;,\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\hal;.\nRF5_SDK_11.0.0_89a8197\components\libraries\fstorage\config;.\nRF5_SDK_11.0.0_89a8197\components\libraries\fstorage;.\nRF5_SDK_11.0.0_89a8197\components\libraries\experimental_section_vars;;\nRF5_SDK_11.0.0_89a8197\components\libraries\trace;.\nRF52_DFU\nRF5_SDK_11.0.0_89a8197\components\libraries\trace;.\Sources\algorithm;.\Sources\application;.\Sources\drivers;.\Sources\utils\qrcode;.\Sources\task;.\Sources\osal\inc;.\nRF5_SDK_11.0.0_89a8197\components\libraries\trace;.\Sources\gui;.\Sources\gsensor;.\Sources\utils;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\config;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_services\ble_dis;.\Sources\wechat;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_db_discovery;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_services\ble_ancs_c;.\Sources\ancc;.\nRF5_SDK_11.0.0_89a8197\external\segger_rtt;.\nRF5_SDK_11.0.0_89a8197\components\ble\ble_db_discovery;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\saadc;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\config;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\hal;.\Sources\icon;.\NRF51832_GT24L24A2Y;.\Sources\wdt;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\wdt;.\Sources\lib;.\Sources\fontchip;.\nRF5_SDK_11.0.0_89a8197\components\drivers_nrf\pwm;.\Sources\jpeg;.\Sources\HeartRate
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
  group Applications
    ./Sources/application/: Alarm.c main.c ClockTick.c UserSetting.c btprotocol.c
  group Osal
    ./Sources/osal/src/: OSAL.c OSAL_PwrMgr.c OSAL_Task.c OSAL_TaskDemo.c OSAL_Timer.c
  group Task
    ./Sources/task/: Task_Battery.c Task_Ble.c Task_GUI.c Task_Step.c Task_Touch.c Task_Upload.c Task_Motor.c Task_Finder.c Task_Hr.c Task_Store.c Task_Frame.c
    ./Sources/utils/: Task_Flash.c
  group nRF_BLE
    ./nRF5_SDK_11.0.0_89a8197/components/ble/ble_services/ble_dfu/: ble_dfu.c
    ./nRF5_SDK_11.0.0_89a8197/components/ble/ble_services/ble_nus/: ble_nus.c
    ./nRF5_SDK_11.0.0_89a8197/components/ble/ble_advertising/: ble_advertising.c
    ./nRF5_SDK_11.0.0_89a8197/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ./nRF5_SDK_11.0.0_89a8197/components/ble/device_manager/: device_manager_peripheral.c
  group nRF_Libraries
    ./nRF5_SDK_11.0.0_89a8197/components/libraries/fstorage/: fstorage.c
    ./nRF5_SDK_11.0.0_89a8197/components/libraries/util/: nrf_assert.c app_error.c app_error_weak.c
    ./nRF5_SDK_11.0.0_89a8197/components/libraries/bootloader_dfu/: bootloader_util.c dfu_app_handler.c
    ./nRF5_SDK_11.0.0_89a8197/components/ble/ble_services/ble_ancs_c/: ble_ancs_c.c
    ./nRF5_SDK_11.0.0_89a8197/components/ble/ble_db_discovery/: ble_db_discovery.c
  group nRF_Drivers
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/pstorage/: pstorage.c
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/delay/: nrf_delay.c
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/hal/: nrf_saadc.c
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/pwm/: nrf_drv_pwm.c
    ./nRF5_SDK_11.0.0_89a8197/components/drivers_nrf/common/: nrf_drv_common.c
  group nRF_SoftDevice
    ./nRF5_SDK_11.0.0_89a8197/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group Custom_Drivers
    ./Sources/drivers/: IRQHandler.c SPI_HW.c Button.c FPU.c SSADC.c Debug.c LCD_ST7735.c PWM.c
  group GSensor
    ./Sources/gsensor/: bma2x2.c bma253.c
  group Algorithm
    ./Sources/algorithm/: step_process.c sleep_algorithm.c LookTable.c SkippingAlg.c
  group Utils
    ./Sources/utils/qrcode/: QR_Encode.c QR_Utils.c
    ./Sources/utils/: U2K.c
  group Wechat
    ./Sources/wechat/: ble_wechat_service.c
  group Ancs
    ./Sources/ancc/: Ancs.c
    ./Sources/utils/: MsgQueue.c
    ./NRF51832_GT24L24A2Y/: nrf52832_xxaa.lib
  group GUI
    ./Sources/gui/: UI_win_main.c UI_win_pedometer.c UI_win_sport.c UI_win_hr.c UI_win_sleep.c UI_win_alarm.c UI_win_timer.c UI_win_findphone.c UI_win_info.c UI_win_shutdown.c UI_win_camera.c UI_win_notify.c UI_Comm_Draw.c Window.c UI_win_bpressure.c UI_Draw.c UI_win_more.c
  group Icon
    ./Sources/icon/: UI_main_icon.c UI_pedometer_icon.c UI_sport_icon.c UI_sleep_icon.c UI_hr_icon.c Ui_alarm_icon.c UI_findphone_icon.c UI_info_icon.c UI_shutdown_icon.c UI_camera_icon.c UI_comm_icon.c UI_notify_icon.c UI_timer_icon.c UI_bp_icon.c UI_more_icon.c
  group WDT
    ./Sources/wdt/: wdt.c
  group LIB
    ./Sources/lib/: HeartRate.lib Energy.lib jpeg_decode.lib jpeg_decode.h
  group FontChip
    ./Sources/ancc/: SPI.c
    ./Sources/fontchip/: FontChip.c
  group HeartRate
    ./Sources/HeartRate/: em70x8.c em70x8_gpio_i2c.c HeartRatelib.lib libBp.lib
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
